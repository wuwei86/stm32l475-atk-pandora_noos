# Keil uVision project usb.uvprojx, settings and files
target usb (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usb +hex
  AfterMake: fromelf.exe --bin -o "@L.bin"  "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L475xx
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../FATFS/Target;../FATFS/App;../USB_HOST/App;../USB_HOST/Target;../Middlewares/Third_Party/FatFs/src;../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;..\easylogger\inc;..\Core\Inc\LCD;..\Core\Inc\SPI3;..\Core\Inc\delay;..\Core\Inc\sys;..\UIcode;..\Core\Inc\W25QXX;..\Core\Inc\QSPI;..\SFUD\inc;..\easyflash\inc;..\letter-shell\port;..\letter-shell\src;..\cJSON;..\easylogger\plugins\flash;..\Core\Inc\SD_CARD;..\Core\Inc\SPI1;..\Core\Inc\SPI;..\easylogger\plugins\file;..\freemodbus\modbus\include;..\freemodbus\port;..\freemodbus\modbus\ascii;..\freemodbus\modbus\rtu;..\freemodbus\modbus\tcp;..\freemodbus\modbus\functions;..\Core\Inc\TIMER;..\Core\Inc\LED;..\Core\Inc\BEEP;..\Core\Inc\EXTI;..\Core\Inc\IWDG;..\Core\Inc\KEY;..\Core\Inc\WWDG;..\MultiTimer;..\MultiButton;..\LVGL;..\LVGL\examples\porting;..\LVGL\examples\get_started;..\LVGL\examples\anim;..\LVGL\examples\widgets;..\LVGL\examples\libs;..\LVGL\examples\libs\qrcode;..\LVGL\lvgl_app;..\ringbuffer;..\AT-Command;..\Core\Inc\WIFI_AT_ESP8266
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x67000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c bsp.c common.c user_cmd.c
    ../Core/Src/LCD/: lcd.c
    ../Core/Src/delay/: delay.c
    ../Core/Src/sys/: sys.c
    ../Core/Src/W25QXX/: w25qxx.c
    ../Core/Src/QSPI/: qspi.c
    ../Core/Src/SD_CARD/: sd_card.c
    ../Core/Src/SPI/: spi.c
    ../Core/Src/TIMER/: timer.c
    ../Core/Src/LED/: led.c
    ../Core/Src/BEEP/: beep.c
    ../Core/Src/EXTI/: exti.c
    ../Core/Src/IWDG/: iwdg.c
    ../Core/Src/KEY/: key.c
    ../Core/Src/WWDG/: wwdg.c
    ../Core/Src/WIFI_AT_ESP8266/: wifi_task.c wifi_uart.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_hcd.c stm32l4xx_ll_usb.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_qspi.c stm32l4xx_hal_spi_ex.c stm32l4xx_ll_utils.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_wwdg.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: usbh_diskio.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/USB_HOST/App
    ../USB_HOST/App/: usb_host.c
  group Application/User/USB_HOST/Target
    ../USB_HOST/Target/: usbh_conf.c usbh_platform.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group easylogger
    ../easylogger/src/: elog.c elog_utils.c
    ../easylogger/port/: elog_port.c
    ../easylogger/plugins/flash/: elog_flash.c elog_flash_port.c
    ../easylogger/plugins/file/: elog_file.c elog_file_port.c
  group UIcode
    ../UIcode/: UIcode.cpp
    ../UIcode/resource/: Lucida_Console_27.cpp
  group sfud
    ../SFUD/src/: sfud.c sfud_sfdp.c
    ../SFUD/port/: sfud_port.c
  group easyflash
    ../easyflash/port/: ef_port.c
    ../easyflash/src/: easyflash.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_iap.c ef_log.c ef_utils.c
  group letter-shell
    ../letter-shell/src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
    ../letter-shell/port/: shell_port.c
  group cJSON
    ../cJSON/: cJSON.c cJSON_Utils.c cJSON_test.c
  group freemodbus
    ../freemodbus/modbus/ascii/: mbascii.c
    ../freemodbus/modbus/functions/: mbfuncdiag.c mbfuncdisc.c mbfuncdisc_m.c mbfuncholding.c mbfuncholding_m.c mbfuncinput.c mbfuncinput_m.c mbfuncother.c mbutils.c mbfunccoils.c
    ../freemodbus/modbus/rtu/: mbcrc.c mbrtu.c mbrtu_m.c
    ../freemodbus/modbus/tcp/: mbtcp.c
    ../freemodbus/modbus/: mb.c mb_m.c
  group freemodbus/port
    ../freemodbus/port/: port.c portevent.c portserial.c portevent_m.c portserial_m.c porttimer.c porttimer_m.c user_mb_app.c user_mb_app_m.c
  group MultiTimer
    ../MultiTimer/: MultiTimer.c test_stm32.c
  group MultiButton
    ../MultiButton/: example_callback.c example_poll.c multi_button.c
  group lvgl
    ../LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../LVGL/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../LVGL/src/gpu/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.c lv_gpu_stm32_dma2d.c
    ../LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../LVGL/src/misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../LVGL/src/extra/layouts/flex/: lv_flex.c
    ../LVGL/src/extra/layouts/grid/: lv_grid.c
    ../LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../LVGL/src/extra/themes/default/: lv_theme_default.c
    ../LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../LVGL/src/extra/widgets/chart/: lv_chart.c
    ../LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../LVGL/src/extra/widgets/led/: lv_led.c
    ../LVGL/src/extra/widgets/list/: lv_list.c
    ../LVGL/src/extra/widgets/meter/: lv_meter.c
    ../LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../LVGL/src/extra/widgets/span/: lv_span.c
    ../LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../LVGL/src/extra/widgets/win/: lv_win.c
    ../LVGL/src/extra/: lv_extra.c
    ../LVGL/src/extra/libs/bmp/: lv_bmp.c
    ../LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../LVGL/src/extra/libs/freetype/: lv_freetype.c
    ../LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ../LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ../LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
  group lvgl_port
    ../LVGL/examples/porting/: lv_port_disp.c
  group lvgl_config
    ../LVGL/: lv_conf.h
  group lvgl_example
    ../LVGL/examples/get_started/: lv_example_get_started_1.c lv_example_get_started_2.c lv_example_get_started_3.c
    ../LVGL/examples/anim/: lv_example_anim_1.c lv_example_anim_2.c
    ../LVGL/examples/widgets/keyboard/: lv_example_keyboard_1.c
    ../LVGL/examples/widgets/img/: lv_example_img_2.c
    ../LVGL/examples/assets/: img_cogwheel_argb.c
    ../LVGL/examples/libs/qrcode/: lv_example_qrcode_1.c
  group lvgl_app
    ../LVGL/lvgl_app/: lvgl_button.c lvgl_main_win.c lvgl_qrcode_win.c lvgl_led.c
  group AT-Command
    ../AT-Command/: at_chat.c
  group ringbuffer
    ../ringbuffer/: ringbuffer.c
software components: CMSIS:CORE 5.3.0
